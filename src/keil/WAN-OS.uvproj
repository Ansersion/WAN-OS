# Keil uVision project WAN-OS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: WAN-OS
  c flags: Optim=1
  c include: ..\..\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group kernel
    ../: init.c main.c stm32f10x_usart.c irq.c
    ./: startup_stm32f10x_hd.s asm_tool_keil.s
